# Keil uVision project RTT-DiscoveryF4.uvproj, settings and files
target RTT-DiscoveryF4 (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(180000000) ELITTLE
  output: RTT-DiscoveryF4
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\include;.\BSP\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\BSP\Drivers;.\components\finsh;.\components\drivers\include;.\BSP\Libraries\CMSIS\Include;.\Libcpu\cortex-m4;.\BSP\Libraries\CMSIS\ST\STM32F4xx\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ./BSP/Applications/: application.c startup.c
  group Drivers
    ./BSP/Drivers/: board.c drv_hwtimer.c gpio.c stm32f4xx_it.c usart.c led.c cpuusage.c mpu6500_spi.c drv_can.c bxcan.c
  group STM32_StdPeriph
    ./BSP/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./BSP/Libraries/CMSIS/ST/STM32F4xx/Source/: startup_stm32f4xx.s system_stm32f4xx.c
  group Kernel
    ./Kernel/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Cortex-M4
    ./Libcpu/common/: backtrace.c div0.c showmem.c
    ./Libcpu/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ./components/drivers/misc/: pin.c
    ./components/drivers/serial/: serial.c
    ./components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ./components/drivers/hwtimer/: hwtimer.c
    ./components/drivers/can/: can.c
    ./components/drivers/spi/: spi_dev.c spi_core.c
  group finsh
    ./components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
